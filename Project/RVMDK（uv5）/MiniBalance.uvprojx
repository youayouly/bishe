# Keil uVision project MiniBalance.uvprojx, settings and files
target MiniBalance (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0xC000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: MiniBalance +hex
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1
  c define: STM32F10X_HD, USE_STDPERIPH_DRIVER
  c include: ..\..\Libraries\CMSIS;..\..\User;..\..\Libraries\FWlib\inc;..\..\User\CONTROL;..\..\User\MPU6050\DMP;..\..\User\MPU6050\IIC;..\..\User\MPU6050\MPU6050;..\..\User\MPU6050\filter;..\..\User\HARDWARE;..\..\User\HARDWARE\usartx;..\..\User\HARDWARE\uart
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group STARTUP
    ../../Libraries/CMSIS/startup/: startup_stm32f10x_hd.s
  group CMSIS
    ../../Libraries/CMSIS/: core_cm3.c core_cm3.h stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group FWLB
    ../../Libraries/FWlib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group USER
    ../../User/: main.c stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h Header.h
  group HARDWARE
    ../../User/HARDWARE/beep/: bsp_beep.c
    ../../User/HARDWARE/Key/: bsp_key.c
    ../../User/HARDWARE/Led/: bsp_led.c
    ../../User/HARDWARE/SysTick/: bsp_SysTick.c
    ../../User/HARDWARE/usart/: bsp_usart.c
    ../../User/HARDWARE/GeneralTim/: bsp_GeneralTim.c
    ../../User/HARDWARE/Motor/: bsp_motor.c
    ../../User/HARDWARE/adc/: bsp_adc.c
    ../../User/HARDWARE/OLED/: bsp_oled.c
    ../../User/HARDWARE/encoder/: encoder.c
    ../../User/HARDWARE/PSTWO/: pstwo.c
    ../../User/HARDWARE/DataScope_DP/: DataScope_DP.C
    ../../User/HARDWARE/usartx/: usartx.c
    ../../User/HARDWARE/uart/: uart.c
  group CONTROL
    ../../User/CONTROL/: control.c show.c bluetooth.c pid.c Lidar.c capture.c ELE_CCD.c
  group MPU6050
    ../../User/MPU6050/DMP/: inv_mpu.c inv_mpu_dmp_motion_driver.c
    ../../User/MPU6050/IIC/: IOI2C.c
    ../../User/MPU6050/MPU6050/: MPU6050.c
    ../../User/MPU6050/filter/: filter.c
  group DOC
    ../../Doc/: readme.txt
target stm32 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: as above
  output: MiniBalance +hex
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1
  c define: STM32F10X_HD, USE_STDPERIPH_DRIVER
  c include: ..\..\Libraries\CMSIS;..\..\User;..\..\Libraries\FWlib\inc;..\..\User\CONTROL;..\..\User\MPU6050\DMP;..\..\User\MPU6050\IIC;..\..\User\MPU6050\MPU6050;..\..\User\MPU6050\filter;..\..\User\HARDWARE;..\..\User\HARDWARE\usartx
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
